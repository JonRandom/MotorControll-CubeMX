# IAR project Yukon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; ..\Include; ..\library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Yukon.srec
  ILINK.IlinkOutputFile: Yukon.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group include files
    ../Include/: definitions.h motorcontrolsettings.h
  group Lib
    ../library/src/: stm32f10x_adc.c stm32f10x_flash.c stm32f10x_nvic.c stm32f10x_rcc.c
  group Source
    ../Source/: main.c stm32f10x_it.c
  group Startup
    ./: cortexm3_macro.s stm32f10x_vector.c
